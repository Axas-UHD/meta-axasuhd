SRCDATE = "20180219"

require axas-libgles.inc

SRC_URI[md5sum] = "efd36cc12ca10920a1d546dd3920240b"
SRC_URI[sha256sum] = "a9b31562106c5338b84829766961ce6de3074934abac19070fb3b61272fb2bbe"

COMPATIBLE_MACHINE = "e4hd"