KV = "4.10.12"
SRCDATE = "20180219"

require axas-dvb-modules.inc

SRC_URI[md5sum] = "5a3678a9a691b451b496ca032749cc0b"
SRC_URI[sha256sum] = "f96db6900ad1b03f1b11c5b298a809cb49c98f5fb59cea86f993aa3d9c3ff597"

COMPATIBLE_MACHINE = "e4hdultra"
